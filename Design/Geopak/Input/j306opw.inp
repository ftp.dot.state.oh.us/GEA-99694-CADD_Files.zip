sto pro CLCONSTR306
vpi 1 s 102+43.62 e 1206.502781
vpi 2 s 102+50.00 e 1206.594777
vpi 3 s 103+00.00 e 1207.050677
vpi 4 s 103+50.00 e 1207.156691
vpi 5 s 104+00.00 e 1207.084606
vpi 6 s 104+50.00 e 1207.120766
vpi 7 s 105+00.00 e 1206.964769
vpi 8 s 105+50.00 e 1206.948763
vpi 9 s 106+00.00 e 1206.944914
vpi 10 s 106+50.00 e 1206.917811
vpi 11 s 107+00.00 e 1206.694991
vpi 12 s 107+50.00 e 1206.386668
vpi 13 s 108+00.00 e 1205.991230
vpi 14 s 108+50.00 e 1205.570362
vpi 15 s 109+00.00 e 1205.150708
vpi 16 s 109+50.00 e 1204.819921
vpi 17 s 110+00.00 e 1204.557432
vpi 18 s 110+50.00 e 1204.412831
vpi 19 s 111+00.00 e 1204.261729
vpi 20 s 111+50.00 e 1204.005649
vpi 21 s 112+00.00 e 1203.625671
vpi 22 s 112+50.00 e 1203.115526
vpi 23 s 113+00.00 e 1202.659686
vpi 24 s 113+50.00 e 1202.239308
vpi 25 s 114+00.00 e 1201.896183
vpi 26 s 114+50.00 e 1201.464396
vpi 27 s 115+00.00 e 1200.946122
vpi 28 s 115+50.00 e 1200.477546
vpi 29 s 116+00.00 e 1200.181007
vpi 30 s 116+50.00 e 1199.941209
vpi 31 s 117+00.00 e 1199.678370
vpi 32 s 117+50.00 e 1199.466809
vpi 33 s 118+00.00 e 1199.329752
vpi 34 s 118+50.00 e 1199.213029
vpi 35 s 119+00.00 e 1199.184405
vpi 36 s 119+50.00 e 1199.251681
vpi 37 s 120+00.00 e 1199.433747
vpi 38 s 120+50.00 e 1199.616230
vpi 39 s 121+00.00 e 1199.711239
vpi 40 s 121+50.00 e 1199.849320
vpi 41 s 122+00.00 e 1200.064327
vpi 42 s 122+50.00 e 1200.206003
vpi 43 s 123+00.00 e 1200.248461
vpi 44 s 123+50.00 e 1200.282026
vpi 45 s 123+62.46 e 1200.306941
END PRO
sto pro BLCONSTRESMT
vpi 1 s 20+00.00 e 1200.210435
vpi 2 s 20+50.00 e 1198.186469
vpi 3 s 21+00.00 e 1197.349885
vpi 4 s 21+50.00 e 1195.689715
vpi 5 s 22+00.00 e 1194.299323
vpi 6 s 22+50.00 e 1193.387161
vpi 7 s 23+00.00 e 1192.828548
vpi 8 s 23+50.00 e 1192.199508
vpi 9 s 24+00.00 e 1191.418094
vpi 10 s 24+50.00 e 1190.754188
vpi 11 s 25+00.00 e 1190.342275
vpi 12 s 25+50.00 e 1190.965109
vpi 13 s 25+54.40 e 1190.981356
END PRO
